# Keil uVision project ISP_I2C.uvproj, settings and files
target ISP_I2C (6120000::V6.12::.\ARMCLANG)
  device: NUC123SD4AN0 Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: ISP_I2C
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC123\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC123/Source/: system_NUC123.c
    ../../../../Library/Device/Nuvoton/NUC123/Source/ARM/: startup_NUC123.s
  group User
    ../: main.c fmc_user.c isp_user.c targetdev.c i2c_transfer.c
