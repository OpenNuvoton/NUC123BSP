# Keil uVision project ISP_DFU.uvproj, settings and files
target ISP_DFU (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: NUC123SD4AN0 Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x10FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: ISP_DFU
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC123\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC123_user.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC123/Source/: system_NUC123.c
  group User
    ../: descriptors.c main.c dfu_transfer.c fmc_user.c startup_NUC123_user.s usbd_user.c
