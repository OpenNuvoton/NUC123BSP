# IAR project SYS_PowerDown_MinCurrent.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC123AN series Nuvoton NUC123AN series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\NUC123\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SYS_PowerDown_MinCurrent.bin
  ILINK.IlinkOutputFile: SYS_PowerDown_MinCurrent.out
  ILINK.IlinkIcfFile: SYS_PowerDown_MinCurrent.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC123/Source/IAR/: startup_NUC123.s
    ../../../../Library/Device/Nuvoton/NUC123/Source/: system_NUC123.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c
  group User
    ../: main.c
