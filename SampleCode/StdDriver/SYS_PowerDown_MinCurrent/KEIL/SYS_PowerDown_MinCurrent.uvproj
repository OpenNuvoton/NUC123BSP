# Keil uVision project SYS_PowerDown_MinCurrent.uvproj, settings and files
target SYS_PowerDown_MinCurrent (6160000::V6.16::ARMCLANG)
  device: NUC123SD4AN0 Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x10FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: SYS_PowerDown_MinCurrent
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC123\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC123.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC123/Source/: system_NUC123.c
    ../../../../Library/Device/Nuvoton/NUC123/Source/ARM/: startup_NUC123.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c gpio.c clk.c sys.c uart.c
