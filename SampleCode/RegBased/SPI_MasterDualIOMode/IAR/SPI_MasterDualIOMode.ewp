# IAR project SPI_MasterDualIOMode.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC123AN series Nuvoton NUC123AN series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\NUC123\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPI_MasterDualIOMode.bin
  ILINK.IlinkOutputFile: SPI_MasterDualIOMode.out
  ILINK.IlinkIcfFile: SPI_MasterDualIOMode.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC123/Source/IAR/: startup_NUC123.s
    ../../../../Library/Device/Nuvoton/NUC123/Source/: system_NUC123.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c spi.c uart.c
  group User
    ../: main.c
